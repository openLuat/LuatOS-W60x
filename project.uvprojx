# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rtthread-w60x
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: .\makeimg.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC, WM_W600
  c misc: --c99 --gnu
  c include: .;rt-thread\include;applications;lua;luat;drivers;oneshot;packages\netutils-v1.1.0\ntp;packages\wm_libraries-latest;packages\wm_libraries-latest\Include;packages\wm_libraries-latest\Include\Driver;packages\wm_libraries-latest\Platform\Drivers\spi;packages\wm_libraries-latest\Include\OS;packages\wm_libraries-latest\Include\Platform;packages\wm_libraries-latest\Include\OS;packages\wm_libraries-latest\Include\WiFi;packages\wm_libraries-latest\Platform\Inc;packages\wm_libraries-latest\Platform\Common\Params;packages\wm_libraries-latest\Platform\Common\crypto;packages\wm_libraries-latest\Platform\Common\crypto\digest;packages\wm_libraries-latest\Platform\Common\crypto\math;packages\wm_libraries-latest\Platform\Common\crypto\symmetric;packages\wm_libraries-latest\Platform\Boot\gcc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\hwcrypto;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\wlan;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;rt-thread\components\net\lwip_dhcpd;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;rt-thread\components\utilities\ulog
  memory RVCT4: ROM 0x8010100 size 0xefeff
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    lua/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltests.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
    luat/: luat_lib_gpio.c luat_lib_msgbus.c luat_lib_sys.c luat_lib_timer.c luat_lib_uart.c luat_log_rtt.c luat_main.c luat_malloc_rtt.c luat_msgbus_rtt.c luat_timer_rtt.c
  group Drivers
    drivers/: board.c drv_uart.c drv_flash.c pin_map.c drv_wifi.c drv_pin.c drv_hw_timer.c drv_pwm.c drv_crypto.c
  group oneshot
    oneshot/: oneshot.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group Libraries
    packages/wm_libraries-latest/Platform/Drivers/cpu/: wm_cpu.c
    packages/wm_libraries-latest/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    packages/wm_libraries-latest/Platform/Drivers/io/: wm_io.c
    packages/wm_libraries-latest/Platform/Drivers/irq/: wm_irq.c
    packages/wm_libraries-latest/Platform/Drivers/efuse/: wm_efuse.c
    packages/wm_libraries-latest/Platform/Drivers/internalflash/: wm_internal_fls.c
    packages/wm_libraries-latest/Platform/Drivers/spi/: wm_hostspi.c
    packages/wm_libraries-latest/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    packages/wm_libraries-latest/Platform/Drivers/dma/: wm_dma.c
    packages/wm_libraries-latest/Platform/Drivers/timer/: wm_timer.c
    packages/wm_libraries-latest/Platform/Drivers/watchdog/: wm_watchdog.c
    packages/wm_libraries-latest/Platform/Drivers/i2c/: wm_i2c.c
    packages/wm_libraries-latest/Platform/Drivers/pwm/: wm_pwm.c
    packages/wm_libraries-latest/Platform/Drivers/adc/: wm_adc.c
    packages/wm_libraries-latest/Platform/Drivers/pmu/: wm_pmu.c
    packages/wm_libraries-latest/Platform/Drivers/rtc/: wm_rtc.c
    packages/wm_libraries-latest/Platform/Common/Params/: wm_param.c
    packages/wm_libraries-latest/Platform/Common/fwup/: wm_fwup.c
    packages/wm_libraries-latest/Platform/Common/crypto/: wm_crypto_hard.c
    packages/wm_libraries-latest/Platform/Common/crypto/digest/: wm_crypto_hmac.c wm_crypto_md2.c wm_crypto_md4.c sha224.c sha384.c wm_crypto_sha512.c
    packages/wm_libraries-latest/Platform/Common/crypto/keyformat/: asn1.c wm_crypto_base64.c wm_crypto_x509.c
    packages/wm_libraries-latest/Platform/Common/crypto/math/: pstm_mul_comba.c
    packages/wm_libraries-latest/Platform/Common/crypto/prng/: prng.c yarrow.c
    packages/wm_libraries-latest/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c wm_crypto_rsa.c
    packages/wm_libraries-latest/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    packages/wm_libraries-latest/rtthread/: rtthread_patch.c
    packages/wm_libraries-latest/rtthread/utils/: utils.c
    packages/wm_libraries-latest/rtthread/startup/armcc/: startup_venus.S
    packages/wm_libraries-latest/Platform/Boot/armcc/: misc.c
    packages/wm_libraries-latest/Lib/Wlan/: libwlan_mdk.lib
    packages/wm_libraries-latest/Lib/oneshot/: libwmoneshot_mdk.lib
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/hwcrypto/: hwcrypto.c hw_symmetric.c hw_hash.c hw_rng.c hw_crc.c hw_bignum.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/watchdog/: watchdog.c
    rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip_dhcpd/: dhcp_server_raw.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
